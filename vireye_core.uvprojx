# Keil uVision project vireye_core.uvprojx, settings and files
target STM32F103C8T6 Vireye Core (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: vireye_core +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\USB\inc;.\USB\STM32_USB-FS-Device_Driver\inc;..\vireye
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: display.cpp display.h display_ili9341.cpp display_ili9341.h engine.cpp engine.h hardware.cpp hardware.h helpers.cpp helpers.h input.cpp input.h main.cpp text.cpp text.h mem.cpp mem.h vex_loader.cpp vex_loader.h terminal.h terminal.cpp sdcard.cpp sdcard.h config.h sound.h sound.cpp
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
